# Keil uVision project zwt10_plc_arm.uvprojx, settings and files
target zwt10_plc_arm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zwt10_plc_arm +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTCODE
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: stm32f10x_conf.h main.c app_config.h app_main.c app_plc.c bsp.c fw_delay.c fw_plc_gpio.c fw_plc_spi.c fw_uart485.c fw_afe_gpio.c fw_led_gpio.c fw_flash_spi.c fw_rtc_iic.c fw_timer.c drv_plc.c drv_uart485.c drv_flash.c drv_rtc.c thread_devcfg.c thread_devrst.c thread_mtrd.c thread_mtrdsch.c thread_chnchk.c thread_pte.c thread_tquery.c thread_nconfig.c thread_idalloc.c thread_pmac.c thread_route.c thread_simu.c
software components: CMSIS:CORE 5.1.2
